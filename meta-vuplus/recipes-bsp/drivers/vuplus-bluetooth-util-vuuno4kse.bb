require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

FIRMWARE_PATH="bcm20705"
FIRMWARE_FILE="BCM20705B0.hcd"

SRCDATE = "20261009"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "7241a1be1a7d9e1e86ccded1a5b5f7c4"
SRC_URI[sha256sum] = "298e6fc597ab036c5ef8f0393818ef96ec1898f26aa624b7b21bf1245ee17031"

