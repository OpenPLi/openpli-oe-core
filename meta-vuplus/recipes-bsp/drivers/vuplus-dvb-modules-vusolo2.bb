require vuplus-dvb-modules.inc

KV = "3.3.8"
KV_EXTRA = "-2.0"

DOWNLOADMACHINE = "${MACHINE}"
RELEASEDIR = ""

SRCDATE = "20140424"
SRC_URI[md5sum] = "369dd6e09f2d9fcaa3cff01ab1bec95b"
SRC_URI[sha256sum] = "4a340ed46458b42576f606beb079efb0ba9869edb18c1268c7922bfc94480047"
