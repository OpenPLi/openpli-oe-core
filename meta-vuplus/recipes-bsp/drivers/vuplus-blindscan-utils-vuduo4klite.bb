require vuplus-blindscan-utils-arm.inc
COMPATIBLE_MACHINE = "^(vuduo4klite)$"

INSANE_SKIP:vuplus-blindscan-dvbs-utils = "ldflags"
INSANE_SKIP:vuplus-blindscan-dvbc-utils = "ldflags"
