require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

FIRMWARE_PATH="bcm43569"
FIRMWARE_FILE="BCM43569A2_001.003.004.0060.0109.hcd"

SRCDATE = "20261009"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "d32a911cffbd84f66d729a0b4e14dd4a"
SRC_URI[sha256sum] = "30a26000c91b8a52435f6fcd1bed960b04b11f7c258fd3bc8791d34f9156cedd"

