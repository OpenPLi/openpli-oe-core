require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

FIRMWARE_PATH="bcm20705"
FIRMWARE_FILE="BCM20705B0.hcd"

SRCDATE = "20261009"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "ff4a350d86ae6a6d2be9027a7725c4d0"
SRC_URI[sha256sum] = "720eec0e0f90db662b3cdabb485a1a06fc01cbaefd66fc274ab08c4f77340ebb"
