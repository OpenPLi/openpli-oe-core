require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

FIRMWARE_PATH="bcm20705"
FIRMWARE_FILE="BCM20705B0.hcd"

SRCDATE = "20261009"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "659a2ba48605d1132115b7f8114f130a"
SRC_URI[sha256sum] = "8329db996d7d45b83d1862a8bf0012b0eab36b7cfbb59be2601d00163b09fe70"

