require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

FIRMWARE_PATH="bcm20705"
FIRMWARE_FILE="BCM20705B0.hcd"

SRCDATE = "20261009"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "8f6ebe37396e8693bd2806306a1145e1"
SRC_URI[sha256sum] = "d136cd65b49f026011768b09dfd9dcc67af45dcb3ed038bb35ddc45acd94e541"

