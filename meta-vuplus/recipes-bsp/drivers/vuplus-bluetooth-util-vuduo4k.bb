require vuplus-bluetooth-util.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20261009"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "fef862ab7ae25d6a383207a4ba640b1c"
SRC_URI[sha256sum] = "037433d3cee26c2e2214c23edfe04d01d013ee7f6b2c44de351446bd96e87ae8"
