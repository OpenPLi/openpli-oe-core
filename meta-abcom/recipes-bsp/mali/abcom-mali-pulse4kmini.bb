SRCDATE = "20261118"

require abcom-mali-utgard.inc

SRC_URI[md5sum] = "127f9dcb2e0f0b131b81675ef24eead0"
SRC_URI[sha256sum] = "b3c6d0cb134b807820ff0e677222b3041ceb44a9d1b5f3db797b7719459b4083"

COMPATIBLE_MACHINE = "pulse4kmini"
