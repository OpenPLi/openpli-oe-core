SRCDATE = "20261009"

require zgemma-fastboot.inc

SRC_URI[md5sum] = "76b8bdb0cdb722194f3d5809cf88bce9"
SRC_URI[sha256sum] = "c012be4b2636170da4d47bb47952835e94a3f6717beaada8768b47ae49742d0e"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"
