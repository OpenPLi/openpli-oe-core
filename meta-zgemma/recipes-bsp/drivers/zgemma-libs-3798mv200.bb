SRCDATE = "20261115"

require zgemma-libs.inc

SRC_URI[md5sum] = "1e8da6367d94f042cfafb402b65168c8"
SRC_URI[sha256sum] = "0e6041f189cff42cd897d18e3315c932a578b0c779104c00216c4224649352e3"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9combo$|^h9se$|^h9combose$|^h10$|^i55plus$|^i55se$"
