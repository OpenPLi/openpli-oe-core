SRCDATE = "20261009"

require zgemma-bootlogo.inc

SRC_URI[md5sum] = "69bab9c1c236813e76448bd448c698f0"
SRC_URI[sha256sum] = "364f3b26eb005f6ad2ad78a6ed104a1fa4e43679de9722142222a56372a06632"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"
