SRCDATE = "20261009"

require zgemma-bootargs.inc

SRC_URI[md5sum] = "c6edf9e030b4f041c1d515f45f297453"
SRC_URI[sha256sum] = "b32827c129edc0fa9ee95191d9af4758725941c05dda603f3fbd7a85e40b48f0"

COMPATIBLE_MACHINE = "^h8se$|^h9$|^h9se$|^h9combo$|^h9combose$|^h10$|^i55plus$|^i55se$"
