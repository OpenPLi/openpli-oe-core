DESCRIPTION = "Advanced history zap selector"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://README;md5=b5f3c7ed409cbcc6d849e694f25729ba"

PLUGINNAME = "enigma2-plugin-extensions-historyzapselector"

require dima-plugins.inc
