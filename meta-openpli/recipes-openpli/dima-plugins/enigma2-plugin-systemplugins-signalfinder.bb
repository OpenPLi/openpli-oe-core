DESCRIPTION = "Signal finder for DVB-S2 tuners"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://src/__init__.py;md5=4d83900521db5f5d59df5d45c5823475"

PLUGINNAME = "enigma2-plugin-signalfinder"

require dima-plugins.inc
