DESCRIPTION = "Install/Unistall SAT>IP servers for enigma2"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://README.md;md5=50eef981b99a6204c1c66f0055430178"

PLUGINNAME = "enigma2-plugin-systemplugins-satipserver"
PLUGIN_PATH = "SystemPlugins/SATIPserver"

require dima-plugins.inc
