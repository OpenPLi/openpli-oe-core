DESCRIPTION = "Manages satellites/transponders and satellites.xml"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://README.md;md5=1932cd290960f40f6e6f788ad6835371"

PLUGINNAME = "enigma2-plugin-extensions-ts-sateditor"

require dima-plugins.inc
