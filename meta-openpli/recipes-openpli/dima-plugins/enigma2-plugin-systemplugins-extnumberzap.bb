DESCRIPTION = "Extended number zap addon for enigma2"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://README;md5=2996e0935082e0f3e6d91abf95e750a1"

PLUGINNAME = "Extended-NumberZap"

require dima-plugins.inc
