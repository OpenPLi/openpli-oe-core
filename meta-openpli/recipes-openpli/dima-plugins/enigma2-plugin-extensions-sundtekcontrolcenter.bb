DESCRIPTION = "Control sundtek usb stick from enigma2"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://README.md;md5=c9b50156428015ee825dd71892927813"

PLUGINNAME = "enigma2-plugin-extensions-sundtekcontrolcenter"

require dima-plugins.inc
