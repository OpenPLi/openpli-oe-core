DESCRIPTION = "Auto video clipping switcher for enigma2"
LICENSE = "PD"
LIC_FILES_CHKSUM = "file://README;md5=8eddbaffb25ee762a200b712d7242dbe"

PLUGINNAME = "vcs"

require dima-plugins.inc
