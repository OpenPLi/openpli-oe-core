CCCAMVER = ""

require cccam.inc

SRC_URI[md5sum] = "6d9c1964e0f65278b8f3024772b69d13"
SRC_URI[sha256sum] = "bd4e0b2b088a4a977d431ae1bb85fae142020f7b6f88baba06f9757f1b1cd9e2"
