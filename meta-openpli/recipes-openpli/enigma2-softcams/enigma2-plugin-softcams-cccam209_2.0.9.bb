CCCAMVER = "209"

require cccam.inc

SRC_URI[softcam.md5sum] = "978899af06fd8f5fcdda2a74a890dd16"
SRC_URI[softcam.sha256sum] = "33e3e253c4658f797def7621aafbd17115549bc25ac476ac52c6eccc923066a1"
