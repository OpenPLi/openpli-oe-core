MODULE = "trunk"
OSCAMBIN = "oscam-experimental"
LIBUSB = "-DHAVE_LIBUSB=1"

SUBURI = "svn/oscam;module=trunk;proto=http;scmdata=keep"

ALTERNATIVE_PRIORITY = "20"

require oscam-bin.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"
