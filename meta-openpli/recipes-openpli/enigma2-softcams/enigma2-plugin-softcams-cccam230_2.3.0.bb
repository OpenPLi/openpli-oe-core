CCCAMVER = "230"

require cccam.inc

SRC_URI[softcam.md5sum] = "befff8f25c30dd2a1e18b8885ee0f119"
SRC_URI[softcam.sha256sum] = "6b461d95987b7333dfae51280205cd92558bd04c7ef488e37b058c8652201bdf"
