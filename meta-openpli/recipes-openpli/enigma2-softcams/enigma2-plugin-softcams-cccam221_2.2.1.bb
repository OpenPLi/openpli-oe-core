CCCAMVER = "221"

require cccam.inc

SRC_URI[softcam.md5sum] = "b44bc062cd04670bfb1f91061cd20864"
SRC_URI[softcam.sha256sum] = "52427fb384e918c984c10dda6a8b1f2130eed9b523344ef052ab26c185fc4953"
