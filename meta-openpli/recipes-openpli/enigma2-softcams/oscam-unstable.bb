MODULE = "1.10"
OSCAMBIN = "oscam-unstable"
LIBUSB = "-DHAVE_LIBUSB=0"

SUBURI = "svn/oscam/tags;module=1.10;proto=http;scmdata=keep"

ALTERNATIVE_PRIORITY = "10"

require oscam-bin.inc

LIC_FILES_CHKSUM = "file://LICENCE;md5=d32239bcb673463ab874e80d47fae504"
