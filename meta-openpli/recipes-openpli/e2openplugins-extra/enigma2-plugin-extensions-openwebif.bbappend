inherit pythonnative
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "0001-Revert-Change-insane-default-again.patch"
