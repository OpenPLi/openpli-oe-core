DESCRIPTION = "Ziggo Metal look 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "f0d510f5307c0c0fcc42a1429d0f9d9f02bff3f6"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.metal-look-ziggo"
