DESCRIPTION = "Ziggo Transparent black 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "f843c31827397cac9fdf0668c6c6a4e7bae68bd8"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.transparent-black-ziggo"

