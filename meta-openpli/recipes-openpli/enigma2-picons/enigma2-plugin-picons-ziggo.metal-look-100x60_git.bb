DESCRIPTION = "Ziggo Metal look 100x60 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "66cf71c34eec31791a7fa2a0659901b83d3293e0"

SRC_URI = "git://github.com/Stevie-v/srp.100x60.metal-look-ziggo"
