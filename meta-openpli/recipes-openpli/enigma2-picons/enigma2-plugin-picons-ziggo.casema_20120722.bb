PICON_SATNAMES = "ziggo.casema"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-casema-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "23dcb95a3bd6107ca247b470996731c7"
SRC_URI[sha256sum] = "f942a8bc192859ddf2fa6bdddd15be21b21611f8f9da01f8e2474aba088b17cc"
