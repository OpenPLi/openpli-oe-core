DESCRIPTION = "Ziggo Metal stamp 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "485b61545abb4e0e21920de6e83dde40fc594f67"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.metal-stamp-ziggo"
