PICON_SATNAMES = "ziggo.casema"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-casema-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "6ade229c620a0a5e39c39d03ee4a6f63"
SRC_URI[sha256sum] = "0ae917ff295c6a6fa3b6a34503652bebe098601f981cb50726cd0fdf9cabb7f8"
