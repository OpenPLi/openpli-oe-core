DESCRIPTION = "Ziggo Metal 100x60 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "a941a79c3d642797792bb839400cee9e5ed55ac5"

SRC_URI = "git://github.com/Stevie-v/srp.100x60.metal-ziggo"
