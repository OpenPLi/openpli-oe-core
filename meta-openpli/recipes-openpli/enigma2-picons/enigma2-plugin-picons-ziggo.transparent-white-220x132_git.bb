DESCRIPTION = "Ziggo Transparent white 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "4d36e32d70e157fd28a7200234868767b3f4c2b7"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.transparent-white-ziggo"
