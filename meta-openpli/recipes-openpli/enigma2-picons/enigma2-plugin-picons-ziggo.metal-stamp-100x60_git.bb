DESCRIPTION = "Ziggo Metal stamp 100x60 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "f05c7acb8d5b70ca3005da8f11c71d85fa98f12b"

SRC_URI = "git://github.com/Stevie-v/srp.100x60.metal-stamp-ziggo"
