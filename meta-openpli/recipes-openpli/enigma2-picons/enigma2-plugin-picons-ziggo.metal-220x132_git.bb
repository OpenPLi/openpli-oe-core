DESCRIPTION = "Ziggo Metal 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "4b6f5c2a620c8f1f12a7637bb53a5ccbdd1d6ed8"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.metal-ziggo"
