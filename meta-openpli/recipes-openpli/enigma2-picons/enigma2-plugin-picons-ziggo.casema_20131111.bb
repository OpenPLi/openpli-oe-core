PICON_SATNAMES = "ziggo.casema"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-casema-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "920151165cb2d8ec4ffd2bfa86a12f4d"
SRC_URI[sha256sum] = "4b544170928f81c289f75463ecc1f841587c2c5f1ccd612a047ea014b3462baf"
