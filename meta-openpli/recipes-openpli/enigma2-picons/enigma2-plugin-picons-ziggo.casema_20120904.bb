PICON_SATNAMES = "ziggo.casema"

PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-casema-${PV}.tar.gz"

include enigma2-plugin-picons.inc

SRC_URI[md5sum] = "994ed6acae79aae33a7beb18c7c93982"
SRC_URI[sha256sum] = "aeef3ce2c75949fe7abf7b2fc9b3f756c178d2ce78067b78176be3e82ca964f7"
