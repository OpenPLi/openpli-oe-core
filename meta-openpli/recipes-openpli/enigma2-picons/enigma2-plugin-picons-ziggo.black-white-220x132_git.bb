DESCRIPTION = "Ziggo Black white 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "6d99cf97745df45848a36b44c2a554ea94ee06b7"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.black-white-ziggo"
