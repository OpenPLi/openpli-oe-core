DESCRIPTION = "Delta Dark on While 220x132 picons"
MAINTAINER = "Smokey"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-delta.inc

SRC_URI = "git://github.com/atom89/srp.220x132.dark-on-white-delta"
