DESCRIPTION = "Ziggo Reflection black 220x132 picons"
MAINTAINER = "Stefan"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE;beginline=3;endline=8;md5=17213e93942fd27819359eebdf0341b7"

require enigma2-plugin-picons-ziggo.inc

SRCREV = "5e46956a0856a8cbedd88c323fdef9f5e4ca9efc"

SRC_URI = "git://github.com/Stevie-v/srp.220x132.reflection-black-ziggo"
