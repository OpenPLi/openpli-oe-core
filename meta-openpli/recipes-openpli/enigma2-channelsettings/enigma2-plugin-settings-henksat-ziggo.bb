DESCRIPTION = "Henksat UPC regio Zevenaar"

SETTINGS_FILENAME = "e2_henksat_ziggo"

include henksat.inc
