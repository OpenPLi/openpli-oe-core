DESCRIPTION = "Morph883 13E-16E channel settings"

SETTINGS_FILENAME = "Morph883_13E-16E"

include morph883.inc
