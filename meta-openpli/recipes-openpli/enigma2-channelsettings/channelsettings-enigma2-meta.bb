require conf/license/openpli-gplv2.inc

DESCRIPTION = "meta file for settings"

inherit allarch

DEPENDS = "\
	enigma2-plugin-settings-hans-19e-23e \
	enigma2-plugin-settings-hans-19e-23e-basis \
	enigma2-plugin-settings-hans-19e-23e-28e \
	enigma2-plugin-settings-hans-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e-rotating \
	enigma2-plugin-settings-hans-kabelnl \
	\
	enigma2-plugin-settings-morph883-0.8w-13e-19.2e-28.2e \
	enigma2-plugin-settings-morph883-0.8w-13e-19.2e \
	enigma2-plugin-settings-morph883-0.8w-13e \
	enigma2-plugin-settings-morph883-0.8w-4.8e-13e \
	enigma2-plugin-settings-morph883-13e-16e-19.2e-23.5e \
	enigma2-plugin-settings-morph883-13e-16e-19.2e \
	enigma2-plugin-settings-morph883-13e-16e \
	enigma2-plugin-settings-morph883-13e-19.2e-23.5e \
	enigma2-plugin-settings-morph883-13e-19.2e-23.5e-28.2e \
	enigma2-plugin-settings-morph883-13e-19.2e-28.2e \
	enigma2-plugin-settings-morph883-13e-19.2e-42e \
	enigma2-plugin-settings-morph883-13e-19.2e \
	enigma2-plugin-settings-morph883-13e-23.5e \
	enigma2-plugin-settings-morph883-13e-28.2e \
	enigma2-plugin-settings-morph883-13e-42e \
	enigma2-plugin-settings-morph883-13e \
	enigma2-plugin-settings-morph883-30w-13e-19.2e \
	enigma2-plugin-settings-morph883-30w-13e \
	enigma2-plugin-settings-morph883-4.8e-13e-19.2e \
	enigma2-plugin-settings-morph883-4.8e-13e \
	enigma2-plugin-settings-morph883-9e-13e-19.2e \
	enigma2-plugin-settings-morph883-9e-13e \
	enigma2-plugin-settings-morph883-motor \
	\
	enigma2-plugin-settings-ciefp-e2-10sat-39e-28e-23e-19e-16e-13e-9e-4.8e-1.9e-0.8w \
	enigma2-plugin-settings-ciefp-e2-13sat-42e-39e-28e-23e-19e-16e-13e-9e-7e-4.8e-1.9e-0.8w-5w \
	enigma2-plugin-settings-ciefp-e2-16sat-42e-39e-28e-26e-23e-19e-16e-13e-10e-9e-7e-4.8e-1.9e-0.8w-4w-5w \
	enigma2-plugin-settings-ciefp-e2-18sat-42e-39e-36e-33e-28e-26e-23e-19e-16e-13e-10e-9e-7e-4.8e-1.9e-0.8w-4w-5w \
	enigma2-plugin-settings-ciefp-e2-1sat-19e \
	enigma2-plugin-settings-ciefp-e2-2sata-19e-13e \
	enigma2-plugin-settings-ciefp-e2-2satb-19e-16e \
	enigma2-plugin-settings-ciefp-e2-3sata-9e-10e-13e \
	enigma2-plugin-settings-ciefp-e2-3satb-19e-16e-13e \
	enigma2-plugin-settings-ciefp-e2-4sata-28e-19e-13e-30w \
	enigma2-plugin-settings-ciefp-e2-4satb-19e-16e-13e-0.8w \
	enigma2-plugin-settings-ciefp-e2-5sat-19e-16e-13e-1.9e-0.8w \
	enigma2-plugin-settings-ciefp-e2-6sat-23e-19e-16e-13e-1.9e-0.8w \
	enigma2-plugin-settings-ciefp-e2-7sat-23e-19e-16e-13e-4.8e-1.9e-0.8w \
	enigma2-plugin-settings-ciefp-e2-8sat-28e-23e-19e-16e-13e-4.8e-1.9e-0.8w \
	enigma2-plugin-settings-ciefp-e2-9sat-39e-28e-23e-19e-16e-13e-4.8e-1.9e-0.8w \
	enigma2-plugin-settings-ciefp-e2-motor-75e-34w \
	"
