DESCRIPTION = "Henksat UPC regio Amsterdam"

SETTINGS_FILENAME = "e2_henksat_upc-regio_amsterdam"

include henksat.inc
