DESCRIPTION = "Morph883 4.8E-13E channel settings"

SETTINGS_FILENAME = "morph883_4.8E-13E"

include morph883.inc
