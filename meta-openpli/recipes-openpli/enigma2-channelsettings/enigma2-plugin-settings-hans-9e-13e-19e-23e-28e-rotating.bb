DESCRIPTION = "Hans 9E,13E,19E,23E,28E and rotating"

RPROVIDES_${PN} = "e2_hanssettings_13e_19e_23e_28e_AND_rotating"
RREPLACES_${PN} = "e2_hanssettings_13e_19e_23e_28e_AND_rotating"
RCONFLICTS_${PN} = "e2_hanssettings_13e_19e_23e_28e_AND_rotating"

SETTINGS_FILENAME = "e2_hanssettings_9e_13e_19e_23e_28e_AND_rotating"

include hans.inc
