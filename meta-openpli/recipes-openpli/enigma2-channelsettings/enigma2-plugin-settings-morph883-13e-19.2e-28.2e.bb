DESCRIPTION = "Morph883 13E-19.2E-28.2E channel settings"

SETTINGS_FILENAME = "morph883_13E-19.2E-28.2E"

include morph883.inc
