DESCRIPTION = "Ciefp 19E,16E,13E"

SETTINGS_FILENAME = "ciefp-E2-3satB-19E-16E-13E"

include ciefp.inc
