DESCRIPTION = "Morph883 13E-19.2E-23.5E-28.2E channel settings"

SETTINGS_FILENAME = "morph883_13e-19.2e-23.5e-28.2e"

include morph883.inc
