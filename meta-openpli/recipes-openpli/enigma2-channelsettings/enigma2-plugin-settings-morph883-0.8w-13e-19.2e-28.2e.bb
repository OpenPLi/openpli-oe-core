DESCRIPTION = "Morph883 0.8W-13E-19.2E-28.2E channel settings"

SETTINGS_FILENAME = "morph883_0.8W-13E-19.2E-28.2E"

include morph883.inc
