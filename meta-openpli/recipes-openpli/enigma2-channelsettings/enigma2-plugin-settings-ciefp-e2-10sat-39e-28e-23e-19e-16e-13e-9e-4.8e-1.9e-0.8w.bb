DESCRIPTION = "Ciefp 39E,28E,23E,19E,16E,13E,9E,4.8E,1.9E,0.8W"


SETTINGS_FILENAME = "ciefp-E2-10sat-39E-28E-23E-19E-16E-13E-9E-4.8E-1.9E-0.8W"

include ciefp.inc
