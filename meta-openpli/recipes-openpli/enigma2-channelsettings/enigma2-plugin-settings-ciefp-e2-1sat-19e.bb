DESCRIPTION = "Ciefp 19E"

SETTINGS_FILENAME = "ciefp-E2-1sat-19E"

include ciefp.inc
