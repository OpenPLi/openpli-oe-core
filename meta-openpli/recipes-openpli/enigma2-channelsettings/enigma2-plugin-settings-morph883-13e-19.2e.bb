DESCRIPTION = "Morph883 13E-19.2E channel settings"

SETTINGS_FILENAME = "Morph883_13E-19.2E"

include morph883.inc
