DESCRIPTION = "Morph883 9E-13E-19.2E channel settings"

SETTINGS_FILENAME = "morph883_9E-13E-19.2E"

include morph883.inc
