DESCRIPTION = "Henksat Ziggo regio 5555"

SETTINGS_FILENAME = "e2_henksat_ziggo-regio_5555"

include henksat.inc
