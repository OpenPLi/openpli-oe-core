DESCRIPTION = "Ciefp 42E,39E,28E,26E,23E,19E,16E,13E,10E,9E,7E,4.8E,1.9E,0.8W,4W,5W"

SETTINGS_FILENAME = "ciefp-E2-16sat-42E-39E-28E-26E-23E-19E-16E-13E-10E-9E-7E-4.8E-1.9E-0.8w-4W-5w"

include ciefp.inc
