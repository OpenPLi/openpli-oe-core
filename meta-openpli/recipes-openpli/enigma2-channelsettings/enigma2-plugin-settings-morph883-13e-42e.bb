DESCRIPTION = "Morph883 13E-42E channel settings"

SETTINGS_FILENAME = "morph883_13E-42E"

include morph883.inc
