DESCRIPTION = "Morph883 0.8W-13E-19.2E channel settings"

SETTINGS_FILENAME = "Morph883_0.8W-13E-19.2E"

include morph883.inc
