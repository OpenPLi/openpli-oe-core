DESCRIPTION = "Morph883 13E-23.5E channel settings"

SETTINGS_FILENAME = "Morph883_13E-23.5E"

include morph883.inc
