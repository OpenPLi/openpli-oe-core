DESCRIPTION = "Morph883 13E-16E-19.2E channel settings"

SETTINGS_FILENAME = "morph883_13E-16E-19.2E"

include morph883.inc
