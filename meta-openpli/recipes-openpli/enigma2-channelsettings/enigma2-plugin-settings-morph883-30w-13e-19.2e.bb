DESCRIPTION = "Morph883 30W-13E-19.2E channel settings"

SETTINGS_FILENAME = "morph883_30W-13E-19.2E"

include morph883.inc
