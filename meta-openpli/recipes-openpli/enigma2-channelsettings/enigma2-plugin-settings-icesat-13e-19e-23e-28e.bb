DESCRIPTION = "IceSat 13E,19E,23E,28E"

SETTINGS_FILENAME = ""

include icesat.inc
