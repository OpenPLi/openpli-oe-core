DESCRIPTION = "Ciefp 9E,10E,13E"


SETTINGS_FILENAME = "ciefp-E2-3satA-9E-10E-13E"

include ciefp.inc
