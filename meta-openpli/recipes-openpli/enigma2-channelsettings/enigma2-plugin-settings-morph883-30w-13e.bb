DESCRIPTION = "Morph883 30W-13E channel settings"

SETTINGS_FILENAME = "morph883_30W-13E"

include morph883.inc
