DESCRIPTION = "Morph883 13E channel settings"

SETTINGS_FILENAME = "Morph883_13E"

include morph883.inc
