DESCRIPTION = "Ciefp 42E,39E,28E,23E,19E,16E,13E,9E,7E,4.8E,1.9E,0.8w,5w"

SETTINGS_FILENAME = "ciefp-E2-13sat-42E-39E-28E-23E-19E-16E-13E-9E-7E-4.8E-1.9E-0.8w-5w"

include ciefp.inc
