DESCRIPTION = "Morph883 Motor channel settings"

SETTINGS_FILENAME = "morph883_Motor"

include morph883.inc
