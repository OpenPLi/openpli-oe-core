DESCRIPTION = "Morph883 13E-16E-19.2E-23.5E channel settings"

SETTINGS_FILENAME = "Morph883_13E-16E-19.2E-23.5E"

include morph883.inc
