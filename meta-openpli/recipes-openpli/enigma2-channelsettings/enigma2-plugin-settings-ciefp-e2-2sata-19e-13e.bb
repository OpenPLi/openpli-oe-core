DESCRIPTION = "Ciefp 19E,13E"

SETTINGS_FILENAME = "ciefp-E2-2satA-19E-13E"

include ciefp.inc
