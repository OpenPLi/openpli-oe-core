DESCRIPTION = "Morph883 0.8W-13E channel settings"

SETTINGS_FILENAME = "morph883_0.8W-13E"

include morph883.inc
