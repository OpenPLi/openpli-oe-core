DESCRIPTION = "Ciefp motor 75E-34W"

SETTINGS_FILENAME = "ciefp-E2-motor-75E-34W"

include ciefp.inc
