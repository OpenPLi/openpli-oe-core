DESCRIPTION = "Hans 19E,23E basis"

SETTINGS_FILENAME = "e2_hanssettings_19_23_basis"

include hans.inc
