DESCRIPTION = "Morph883 9E-13E channel settings"

SETTINGS_FILENAME = "Morph883_9E-13E"

include morph883.inc
