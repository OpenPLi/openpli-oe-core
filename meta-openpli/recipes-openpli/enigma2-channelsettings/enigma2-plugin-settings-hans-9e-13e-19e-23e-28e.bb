DESCRIPTION = "Hans 9E 13E,19E,23E,28E"

RPROVIDES_${PN} = "e2_hanssettings_13e_19e_23e_28e"
RREPLACES_${PN} = "e2_hanssettings_13e_19e_23e_28e"
RCONFLICTS_${PN} = "e2_hanssettings_13e_19e_23e_28e"

SETTINGS_FILENAME = "e2_hanssettings_9e_13e_19e_23e_28e"

include hans.inc
