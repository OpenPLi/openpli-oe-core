DESCRIPTION = "Henksat UPC regio Zevenaar"

SETTINGS_FILENAME = "e2_henksat_upc-regio_zevenaar"

include henksat.inc
