DESCRIPTION = "Hans Cable-settings"

SETTINGS_FILENAME = "e2_hanssettings_kabelNL"

include hans.inc

