MODULE = "XPower"
DESCRIPTION = "remote PC power management for win and linux"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
