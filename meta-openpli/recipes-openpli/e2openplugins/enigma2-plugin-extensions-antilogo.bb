MODULE = "AntiLogo"
DESCRIPTION = "Prevent logo retention"

require conf/license/license-gplv2.inc

require openplugins-replace-pli.inc

require openplugins-distutils.inc
