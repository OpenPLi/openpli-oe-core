MODULE = "ScreenPosition"
DESCRIPTION = "Adjust the screen position"
PACKAGE_ARCH = "${MACHINE_ARCH}"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
