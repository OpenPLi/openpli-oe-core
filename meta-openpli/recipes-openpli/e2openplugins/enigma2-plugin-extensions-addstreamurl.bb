MODULE = "AddStreamUrl"
DESCRIPTION = "Add a stream url to your channellist"

require conf/license/license-gplv2.inc

require openplugins-replace-pli.inc

require openplugins-distutils.inc

PR="r0"
