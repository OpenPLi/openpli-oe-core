MODULE = "AnalogClock"
DESCRIPTION = "permanent analog clock on the screen"

require conf/license/license-gplv2.inc

require openplugins-replace-pli.inc

require openplugins-distutils.inc
