RDEPENDS:${PN} = " libltdl "
