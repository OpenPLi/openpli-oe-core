RSUGGESTS_${PN} = ""
PACKAGECONFIG = "gpl bzip2 x264 vpx mp3lame"
