PRINC = "2"

RSUGGESTS_${PN} = ""
PACKAGECONFIG = "bzip2 x264 vpx mp3lame"
