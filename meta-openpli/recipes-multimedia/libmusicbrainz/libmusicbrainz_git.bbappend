# out-of-tree building doesn't appear to work for this package.
B = "${S}"
