# Get rid of udev dependency
PACKAGECONFIG = ""
