SRC_URI += "file://0001-doxygen-meson.build-remove-dependency-on-doxygen-bin.patch \
           "
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
