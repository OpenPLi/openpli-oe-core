FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI =+ "file://0002-Allows-manual-selection-of-subtitles.patch \
            file://0001-tryfix-missing-Handling-eit-Subtitle.patch \
           "
