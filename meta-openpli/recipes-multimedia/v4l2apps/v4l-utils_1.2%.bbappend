INSANE_SKIP = "32bit-time"
