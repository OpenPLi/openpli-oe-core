FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# Do not strip binary 
#INHIBIT_PACKAGE_STRIP = "1" 
#do_strip[noexec] = "1" 
#do_strip="no" 
#do_strip(){ 
#        pass 
#}
