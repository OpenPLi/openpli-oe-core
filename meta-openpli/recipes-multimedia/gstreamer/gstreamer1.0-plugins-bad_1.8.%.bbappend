PACKAGECONFIG_append = " faac faad libmms rtmp"
