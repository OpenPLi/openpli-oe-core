PACKAGECONFIG += "amrnb amrwb cdio dvdread mad"
