PACKAGECONFIG += "faac faad libmms rtmp"
