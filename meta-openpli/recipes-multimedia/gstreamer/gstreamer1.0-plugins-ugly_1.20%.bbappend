PACKAGECONFIG = "${GSTREAMER_ORC} amrnb amrwb a52dec mpeg2dec cdio" 
