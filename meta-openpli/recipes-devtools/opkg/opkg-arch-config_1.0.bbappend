# This pointless append only serves to alter the compile signature
# of this recipe so that it gets rebuilt.

do_compile_append() {
	# Just changes the signature
}
