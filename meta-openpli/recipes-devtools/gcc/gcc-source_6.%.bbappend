SRC_URI =+ " \
	file://ubsan-fix-check-empty-string.patch;patch=1 \
	"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
