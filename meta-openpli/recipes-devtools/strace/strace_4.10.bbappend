SRC_URI += "file://strace-0001-sigaction-wrap-sa_restorer-in-ifdef-SA_RESTORER-cons.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
