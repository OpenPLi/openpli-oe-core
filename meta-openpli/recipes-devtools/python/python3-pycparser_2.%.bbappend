RDEPENDS_${PN}_class-target:remove = "\
	cpp \
	cpp-symlinks \
"
