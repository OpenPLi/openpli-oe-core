CFLAGS_append = " -pthread"
