include ${@bb.utils.contains("PYTHON_PN", "python", "python-package-split.inc", "", d)}
