RDEPENDS_${PN}_class-target_remove = "\
	cpp \
	cpp-symlinks \
"

include python-package-split.inc
