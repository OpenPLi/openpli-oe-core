RDEPENDS_${PN} += "libusb1"

include ${PYTHON_VER}-package-split.inc
