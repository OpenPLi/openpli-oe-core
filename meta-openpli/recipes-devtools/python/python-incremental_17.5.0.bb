inherit setuptools
require python-incremental.inc
include python-package-split.inc
