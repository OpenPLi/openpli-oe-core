PR = "r3"

SRC_URI += " \
	file://python-daap.patch \
"
