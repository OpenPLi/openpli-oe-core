include ${PYTHON_PN}-package-split.inc
INSANE_SKIP_${PN} = "installed-vs-shipped"
