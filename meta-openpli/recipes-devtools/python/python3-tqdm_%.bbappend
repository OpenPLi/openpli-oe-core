require python3-package-split.inc
