SRC_URI_remove = "file://0001-When-cross-installing-execute-package-scriptlets-wit.patch"
