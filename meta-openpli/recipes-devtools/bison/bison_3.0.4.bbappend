# REMOVE ME ONCE WE UPDATE OE-CORE

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://gnulib.patch \
	"
