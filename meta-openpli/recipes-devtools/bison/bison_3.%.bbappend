FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append := "file://0001-bison-glibc228.patch"
