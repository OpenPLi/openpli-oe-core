SRC_URI += "file://pseudo-glibc-rtld-next-workaround.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
