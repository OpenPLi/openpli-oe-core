PROVIDES += "nodejs"
RPROVIDES_${PN} += "nodejs"
RCONFLICTS_${PN} = "nodejs"
RREPLACES_${PN} = "nodejs"
