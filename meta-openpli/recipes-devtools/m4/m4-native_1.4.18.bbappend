# REMOVE ME ONCE WE UPDATE OE-CORE

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://m4-1.4.18-glibc-change-work-around.patch \
	"
