FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append := "file://0001-m4-glibc228.patch"
