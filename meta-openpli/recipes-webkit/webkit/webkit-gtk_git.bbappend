FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-g_thread_init-not-found.patch"
