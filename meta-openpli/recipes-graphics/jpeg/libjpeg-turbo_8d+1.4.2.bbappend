FILESEXTRAPATHS_append := "${THISDIR}/files"

SRC_URI += "file://mips32el-nf-detect.patch;striplevel=0;apply=yes"
