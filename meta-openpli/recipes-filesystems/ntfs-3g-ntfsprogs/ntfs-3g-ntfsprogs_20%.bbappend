# Remove unneeded util-linux-mount from RDEPENDS and RRECOMMENDS
RRECOMMENDS:ntfs-3g = ""
