# Remove unneeded util-linux-mount from RRECOMMENDS
RRECOMMENDS:${PN} = ""
