FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://groff-1.22.4-signbit-def-1.patch"
