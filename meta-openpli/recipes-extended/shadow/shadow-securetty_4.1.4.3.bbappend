PR = "r3"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
