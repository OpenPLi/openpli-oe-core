ALTERNATIVE_PRIORITY = "10"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
