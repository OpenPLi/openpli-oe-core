require linux-vuplus-3.3.8.inc

MACHINE_KERNEL_PR_append = "${PR_INC}.5"

COMPATIBLE_MACHINE = "vusolo2"
