SRC_URI = "git://github.com/availink/linux-firmware-availink.git;protocol=https"

SRCREV = "f38a3a9b9906d192075984c7ac1100d51adf75a1"
