FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0004-revert-update-ca-certificates-to-using-c_rehash.patch"
