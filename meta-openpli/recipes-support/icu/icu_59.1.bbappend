FILESEXTRAPATHS_prepend := "${THISDIR}/icu:"
SRC_URI += "file://icudt59l.zip"
