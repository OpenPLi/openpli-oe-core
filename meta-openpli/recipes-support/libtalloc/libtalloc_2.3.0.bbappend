# rebased to fix QA about patch fuzz in OE-zeus ver 2.3.0
FILESEXTRAPATHS_prepend := "${THISDIR}:"
