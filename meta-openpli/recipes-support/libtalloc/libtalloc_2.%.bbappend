inherit python3targetconfig
