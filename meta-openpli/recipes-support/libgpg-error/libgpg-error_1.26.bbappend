# REMOVE ME ONCE WE UPDATE OE-CORE

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://libgpg-error-1.36-gawk5-support.patch \
	"
