PACKAGECONFIG:remove = "icu"
PACKAGECONFIG:append = " idn2"
