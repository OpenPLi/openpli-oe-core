FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
	file://0001-remove-hosttools-path-for-ssh.patch \
	"
