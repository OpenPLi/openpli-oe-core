PV = "1.6.x+git${SRCPV}"
SRCREV = "9cfe6b0197ffadb4e224463953056132f9a863dc"
SRC_URI = "git://github.com/mrjimenez/pupnp.git;branch=branch-1.6.x;protocol=https"
