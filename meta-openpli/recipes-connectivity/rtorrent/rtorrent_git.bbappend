DEPENDS_remove = "libsigc++-2.0"
DEPENDS_append = " libsigc++-3"
