DEPENDS:remove = "libsigc++-2.0"
DEPENDS:append = " libsigc++-3"
