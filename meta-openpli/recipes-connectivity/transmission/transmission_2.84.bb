require transmission.inc

SRC_URI[archive.md5sum] = "411aec1c418c14f6765710d89743ae42"
SRC_URI[archive.sha256sum] = "a9fc1936b4ee414acc732ada04e84339d6755cd0d097bcbd11ba2cfc540db9eb"

