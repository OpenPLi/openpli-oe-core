require transmission.inc

SRC_URI[archive.md5sum] = "a23a32672b83c89b9b61e90408f53d98"
SRC_URI[archive.sha256sum] = "9144652fe742f7f7dd6657716e378da60b751aaeda8bef8344b3eefc4db255f2"

