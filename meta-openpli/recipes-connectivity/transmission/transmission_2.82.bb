require transmission.inc

SRC_URI[archive.md5sum] = "a5ef870c0410b12d10449c2d36fa4661"
SRC_URI[archive.sha256sum] = "3996651087df67a85f1e1b4a92b1b518ddefdd84c654b8df6fbccb0b91f03522"
