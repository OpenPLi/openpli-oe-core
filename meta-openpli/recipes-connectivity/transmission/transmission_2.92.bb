require transmission.inc

SRC_URI[archive.md5sum] = "3fce404a436e3cd7fde80fb6ed61c264"
SRC_URI[archive.sha256sum] = "3a8d045c306ad9acb7bf81126939b9594553a388482efa0ec1bfb67b22acd35f"

