require transmission.inc

SRC_URI[archive.md5sum] = "c92829294edfa391c046407eeb16358a"
SRC_URI[archive.sha256sum] = "35442cc849f91f8df982c3d0d479d650c6ca19310a994eccdaa79a4af3916b7d"

