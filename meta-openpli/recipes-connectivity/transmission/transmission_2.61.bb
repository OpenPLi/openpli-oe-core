require transmission.inc

SRC_URI[archive.md5sum] = "a7849550d82d8a51ddaacd35edc8afe0"
SRC_URI[archive.sha256sum] = "5750d2bcd9bf95bff8f36d01a889a2f0ff8651504ee5f5c05f98e5ad8874e4dc"

