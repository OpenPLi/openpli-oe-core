require vuplus-dvb-modules.inc

KV = "3.3.6"
KV_EXTRA = "-1.2"

DOWNLOADMACHINE = "${MACHINE}"
RELEASEDIR = ""

SRCDATE = "20130218"
SRC_URI[md5sum] = "ba095d82f4b75d04034c44f1b0d3edc6"
SRC_URI[sha256sum] = "4b60602d28164f83df032d4546782564c1d6fcb0abcb141cf2942adee94121dd"
