require vuplus-dvb-modules.inc

KV = "3.3.8"
KV_EXTRA = "-2.0"

DOWNLOADMACHINE = "${MACHINE}"
RELEASEDIR = ""

SRCDATE = "20130802"
SRC_URI[md5sum] = "19c713010aad1a175c3bdcf12d7502dc"
SRC_URI[sha256sum] = "22ce07083d7df00726c017f941c2263bdc47a8321c7d3f375aa7c6ea25242999"
