require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "bm750"
RELEASEDIR = ""

SRCDATE = "20130207"
SRC_URI[md5sum] = "d277d2c8907211b8db9049ac36356501"
SRC_URI[sha256sum] = "e58c7d6c3e555ac9aabcfb086cd28c07534819eeba7a3a6b666cb2397097e14b"
