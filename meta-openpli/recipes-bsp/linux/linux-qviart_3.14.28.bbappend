FILESEXTRAPATHS:prepend := "${THISDIR}/gcc:"
SRC_URI += " \
	file://kernel-add-support-for-gcc11.patch \
	"
