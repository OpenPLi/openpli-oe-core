FILESEXTRAPATHS_append := "${THISDIR}/files"
SRC_URI += "file://kernel-gcc7.patch"
