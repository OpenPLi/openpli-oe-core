require dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "86c01f5a0f2756299b86f32ee33dc56c"
SRC_URI[modules.sha256sum] = "8db41f3e630606dcd06352e9a2a4057935f8b889d51102c523e1a8397cf3314c"
