# Make sure it starts before udev
# See https://forums.openpli.org/topic/78702-edision-mio4k-usb-tuner-issue-in-develop-branch/page-5

INITSCRIPT_PARAMS = "start 03 S ."
