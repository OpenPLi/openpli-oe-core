OLDEST_KERNEL = "3.2.0"
