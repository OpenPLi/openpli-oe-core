FILESEXTRAPATHS_append := "${THISDIR}/files"

SRC_URI_append = " file://mips-no-fpu.patch"
