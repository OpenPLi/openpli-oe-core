FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://login-blank-password.patch"
