SUMMARY = "Kodi Media Center PVR plugins"

PV = "20.3.0+git${SRCPV}"
PKGV = "20.3.0+git${GITPKGV}"

KODIADDONPLUGIN = "wmc"

require kodi-addon-pvr.inc
