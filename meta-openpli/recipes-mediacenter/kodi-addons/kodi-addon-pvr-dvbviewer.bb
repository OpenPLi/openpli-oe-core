SUMMARY = "Kodi Media Center PVR plugins"

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://src/client.cpp;md5=6420243dd3ea9f912a7099707dfd3e49"

PV = "20-4-0+git${SRCPV}"
PKGV = "20.4.0+git${GITPKGV}"

KODIADDONPLUGIN = "dvbviewer"

require kodi-addon-pvr.inc
