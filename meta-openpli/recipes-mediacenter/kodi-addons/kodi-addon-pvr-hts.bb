SUMMARY = "Kodi Media Center PVR plugins"

PV = "420.1.2+git${SRCPV}"
PKGV = "20.1.2+git${GITPKGV}"

KODIADDONPLUGIN = "hts"

require kodi-addon-pvr.inc
