SUMMARY = "Kodi Media Center PVR plugins"

PV = "20.5.0+git${SRCPV}"
PKGV = "20.5.0+git${GITPKGV}"

KODIADDONPLUGIN = "argustv"

require kodi-addon-pvr.inc
