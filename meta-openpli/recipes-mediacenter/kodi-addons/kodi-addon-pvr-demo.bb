SUMMARY = "Kodi Media Center PVR plugins"

PV = "20.5.0+git${SRCPV}"
PKGV = "20.6.0+git${GITPKGV}"

KODIADDONPLUGIN = "demo"

require kodi-addon-pvr.inc
