SUMMARY = "Kodi Media Center PVR plugins"

PV = "20.5.0+git${SRCPV}"
PKGV = "20.5.9+git${GITPKGV}"

KODIADDONPLUGIN = "mythtv"

require kodi-addon-pvr.inc
