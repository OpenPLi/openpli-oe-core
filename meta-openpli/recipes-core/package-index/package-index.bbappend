do_package_index[depends] += "openpli-enigma2-image:do_image_complete"
