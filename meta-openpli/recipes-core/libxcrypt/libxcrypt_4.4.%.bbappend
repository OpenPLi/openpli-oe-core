TARGET_CPPFLAGS += "-Wno-error=inline"
