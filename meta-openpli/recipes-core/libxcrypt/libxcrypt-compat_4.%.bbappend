RPROVIDES:${PN} += "libcrypt1 libcrypt.so.1"
