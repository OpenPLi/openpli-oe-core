PR = "r14"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
