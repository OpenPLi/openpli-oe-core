
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
