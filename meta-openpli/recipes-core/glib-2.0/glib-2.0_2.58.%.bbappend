FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI_append += " file://gdbus_Avoid_printing_null_strings.patch "
