# Propagate the MACHINE_EXTRA_RRECOMMENDS changes into the image.
PRINC_dm8000 = "1"
PRINC_dm7020hd = "1"
